# Keil uVision project LED.uvprojx, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HelloWorld
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F469_479xx
  c include: ..\USER;..\LIB\STM32F4xx_StdPeriph_Driver\inc;..\LIB\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\LIB\CMSIS\Include;..\LIB\CMSIS\Device\ST\STM32F4xx\Include;..\HARDWARE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group USER
    ../USER/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h main.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/: led.c
  group LIB
    ../LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group CMSIS
    ../LIB/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../LIB/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Startup
    ../LIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f469_479xx.s
  group README
    ../: readme.txt
